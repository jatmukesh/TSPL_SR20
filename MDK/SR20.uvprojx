# Keil uVision project SR20.uvprojx, settings and files
target SR20 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SR20 +hex
  AfterMake: cmd.exe  /C copy  .\Objects\SR20.hex   .\hex\app
  AfterMake: cmd.exe  /C .\hex\SR20_hex2bin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: MOTO_PWM_EN,PRINTER_LABEL,MOTO_STEP_FX,QR_ENCODE_ENABLE,ENCODE_ENABLE,RD_TYPE_BT,LPS_ADC_TYPE,__USEKEILCOMPILE__,RD_TYPE_SERIAL,RD_EK32_PRINTER,RD_TYPE_SERIAL,PRINTER_58MM,PRINTER_BUFF_RAM,PRINTER_ENGLISH,PRINTER_DIRECT_NOR,PRINTER_AND_USB,PRINTER_LOW_2,
  c include: ..\Librarier\sdk;..\Librarier\core;..\Source;..\BSP;..\PDL;..\Code;..\USB;..\qrcode;..\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x80000
  memory RVCT9: RAM 0x20000 size 0x10000
  scatter file: .\YC3121_keilboot.sct
  group core
    ../Librarier/core/: bt_code.c misc.c system.c cortexm3_macro.s
  group main
    ../Source/: main.c
    ../Code/: macros.h
  group sdk
    ../Librarier/sdk/: yc_gpio.c yc_uart.c yc_bt.c yc_systick.c yc_ipc.c yc_otp.c yc_timer.c yc_lpm.c yc_sysctrl.c yc_power.c yc_qspi.lib yc_spi.c yc_adc.c yc_wdt.c
  group startup
    ../Librarier/startup/: flash_start.s startup.s
  group BSP
    ../BSP/: RD_BT_BSP.c RD_V2_DeviceBSP.c
    ../Code/: HP12832_01_SSD1306_I2C.c
    ../USB/: usb.c
  group DPL
    ../PDL/: PDL.c
  group Code
    ../Code/: PrintCore.C TsplParser.c TsplJob.c TsplRaster.c TsplFirmware.c TsplNative.c TsplReceive.c TsplShared.c ParseESC.c ParseMatrix.c ReceiveBufferPro.c flash.c LabelPro.c BarCode.c OLED_Menu.c
    ../Source/: Audio_Indication.c
  group QRCode
    ../qrcode/: bitstream.c mask.c mmask.c mqrspec.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group MALLOC
    ../MALLOC/: malloc.c
